# Keil uVision project caijiqi_PCB38_FUNC_V01.uvprojx, settings and files
target caijiqi_PCB38_test_lib (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: caijiqi_PCB38_V01 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\myfunc; ..\myfunc\app; ..\myfunc\bsp; ..\myfunc\function; ..\myfunc\mylib_v2019_A; ..\myfunc\sys; ..\myfunc\bsp\mcu; ..\myfunc\bsp\driver; ..\myfunc\bsp\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group mysys
    ../myfunc/sys/: sys.c sys.h sys_config.h sys_define.h
  group mybsp
    ../myfunc/bsp/: bsp.c bsp.h
  group BSP_MCU
    ../myfunc/bsp/mcu/: mcu.c mcu.h com.c com.h uart_mode2.c uart_mode2.h
  group BSP_Driver
    ../myfunc/bsp/driver/: rs485.c rs485.h TM1637.c TM1637.h W25Q64.c W25Q64.h beep.c beep.h driver.h eeprom.c eeprom.h led.c led.h M26.c M26.h EC20.c EC20.h
  group mymain
    ../myfunc/: mymain.c
    ./: readme.txt
  group mylib_v2019_A
    ../myfunc/mylib_v2019_A/: data_transform.c data_transform.h fifo.c fifo.h frame.c frame.h mystring.c mystring.h timeout.c timeout.h typedef.h func_bit.h lock.c lock.h mylib.h socket.c socket.h mymath.c mymath.h communication.c communication.h
  group myfunc
    ../myfunc/function/: caijiqi.c caijiqi.h memory.c memory.h net_debug.h TCP.c TCP.h function.h local_debug.c local_debug.h net_debug.c
software components: CMSIS:CORE 4.3.0
